File: pcb/thumb3-cantor/thumb3-cantor.kicad_pcb (KiCad board)
At the start: 2 copper layers, 75.4 x 35 mm, 7 parts

Commit message: Added label to thumb clusters
Other:
- board text added: "Cantor"
